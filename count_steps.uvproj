# Keil uVision project count_steps.uvproj, settings and files
target MPU6050_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: count_steps +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./program/: main.c MPU6050.c IIC.c DELAY.c Pedometer.c UART.c EEPROM.c LCD1602.c
